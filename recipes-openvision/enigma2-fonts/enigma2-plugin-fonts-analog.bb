# Avoid font extension
FONTNAME = "analog"

require enigma2-fonts.inc
