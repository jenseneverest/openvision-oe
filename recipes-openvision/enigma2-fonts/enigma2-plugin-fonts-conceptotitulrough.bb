# Avoid font extension
FONTNAME = "conceptotitulrough"

require enigma2-fonts.inc
