# Avoid font extension
FONTNAME = "meteocons"

require enigma2-fonts.inc
