# Avoid font extension
FONTNAME = "valis-hd"

require enigma2-fonts.inc
