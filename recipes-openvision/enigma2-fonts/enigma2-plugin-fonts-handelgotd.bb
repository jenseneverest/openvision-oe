# Avoid font extension
FONTNAME = "handelgotd"

require enigma2-fonts.inc
