# Avoid font extension
FONTNAME = "digi"

require enigma2-fonts.inc
