# Avoid font extension
FONTNAME = "tiny"

require enigma2-fonts.inc
