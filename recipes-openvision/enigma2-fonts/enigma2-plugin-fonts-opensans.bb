# Avoid font extension
FONTNAME = "opensans"

require enigma2-fonts.inc
