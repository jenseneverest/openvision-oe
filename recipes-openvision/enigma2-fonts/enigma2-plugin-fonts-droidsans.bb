# Avoid font extension
FONTNAME = "droidsans"

require enigma2-fonts.inc
