MODULE = "Buienradar"
DESCRIPTION = "Buienradar actuele situatie"

require conf/license/license-gplv2.inc
require openplugins-replace-vision.inc
require openplugins-distutils.inc
