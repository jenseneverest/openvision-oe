MODULE = "MagentaMusik360"
DESCRIPTION = "MagentaMusik 360 Plugin"

require conf/license/license-gplv2.inc
require openplugins-replace-vision.inc
require openplugins-distutils.inc
