MODULE = "AntiLogo"
DESCRIPTION = "Prevent logo retention"

require conf/license/license-gplv2.inc
require openplugins-replace-vision.inc
require openplugins-distutils.inc
