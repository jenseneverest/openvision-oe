MODULE = "CacheFlush"
DESCRIPTION = "periodicaly flushing cache"

require conf/license/license-gplv2.inc
require openplugins-replace-vision.inc
require openplugins-distutils.inc
