DESCRIPTION = "Morph883 Motor channel settings"

SETTINGS_FILENAME = "morph883_motor"

include settings-morph883.inc
