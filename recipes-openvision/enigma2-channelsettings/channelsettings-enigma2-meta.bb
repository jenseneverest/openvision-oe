require conf/license/openvision-gplv2.inc

DESCRIPTION = "meta file for settings"

DEPENDS = "\
	enigma2-plugin-extensions-ngsetting \
	enigma2-plugin-settings-chveneburi \
	enigma2-plugin-settings-ciefp-19e.16e.13e.0.8w \
	enigma2-plugin-settings-ciefp-19e.16e.13e.1.9e.0.8w \
	enigma2-plugin-settings-ciefp-19e.16e.13e \
	enigma2-plugin-settings-ciefp-19e.16e \
	enigma2-plugin-settings-ciefp-19e \
	enigma2-plugin-settings-ciefp-23e.19e.16e.13e.1.9e.0.8w \
	enigma2-plugin-settings-ciefp-23e.19e.16e.13e.4.8e.1.9e.0.8w \
	enigma2-plugin-settings-ciefp-39e.23e.19e.16e.13e.4.8e.1.9e.0.8w \
	enigma2-plugin-settings-ciefp-motor.68e.30w.vod \
	enigma2-plugin-settings-hans-19e-23e \
	enigma2-plugin-settings-hans-19e-23e-basis \
	enigma2-plugin-settings-hans-19e-23e-28e \
	enigma2-plugin-settings-hans-13e-19e-23e-28e \
	enigma2-plugin-settings-hans-9e-13e-19e-23e-28e \
	enigma2-plugin-settings-hans-9e-13e-19e-23e-28e-rotating \
	enigma2-plugin-settings-hans-kabelnl \
	enigma2-plugin-settings-morph883-0.8w-13e-19.2e-28.2e \
	enigma2-plugin-settings-morph883-0.8w-13e-19.2e \
	enigma2-plugin-settings-morph883-0.8w-13e \
	enigma2-plugin-settings-morph883-0.8w-4.8e-13e \
	enigma2-plugin-settings-morph883-13e-16e-19.2e-23.5e \
	enigma2-plugin-settings-morph883-13e-16e-19.2e \
	enigma2-plugin-settings-morph883-13e-16e \
	enigma2-plugin-settings-morph883-13e-19.2e-23.5e \
	enigma2-plugin-settings-morph883-13e-19.2e-23.5e-28.2e \
	enigma2-plugin-settings-morph883-13e-19.2e-28.2e \
	enigma2-plugin-settings-morph883-13e-19.2e-42e \
	enigma2-plugin-settings-morph883-13e-19.2e \
	enigma2-plugin-settings-morph883-13e-23.5e \
	enigma2-plugin-settings-morph883-13e-28.2e \
	enigma2-plugin-settings-morph883-13e-42e \
	enigma2-plugin-settings-morph883-13e \
	enigma2-plugin-settings-morph883-30w-13e-19.2e \
	enigma2-plugin-settings-morph883-30w-13e \
	enigma2-plugin-settings-morph883-4.8e-13e-19.2e \
	enigma2-plugin-settings-morph883-4.8e-13e \
	enigma2-plugin-settings-morph883-9e-13e-19.2e \
	enigma2-plugin-settings-morph883-9e-13e \
	enigma2-plugin-settings-morph883-motor \
	"
