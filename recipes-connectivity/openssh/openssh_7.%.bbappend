inherit upx_compress

INSANE_SKIP_${PN} += "textrel"
