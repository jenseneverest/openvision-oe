require recipes-kernel/linux-libc-headers/linux-libc-headers.inc

SRC_URI[md5sum] = "3e58f5ca4b7e6533cfc6d35896c2fbf4"
SRC_URI[sha256sum] = "ba5d53862c2f3762322f8cc7760f4cd0117e86aed78991c62ac4f589bc22189c"
