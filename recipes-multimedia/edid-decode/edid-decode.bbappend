SRC_URI = "https://git.linuxtv.org/edid-decode.git;protocol=https"

CFLAGS_sh4 += "-std=c++11"
