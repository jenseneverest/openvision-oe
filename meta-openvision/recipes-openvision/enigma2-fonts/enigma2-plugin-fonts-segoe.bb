# Avoid font extension
FONTNAME = "segoe"

require enigma2-fonts.inc
