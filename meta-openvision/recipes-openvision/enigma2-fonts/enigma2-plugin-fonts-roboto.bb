# Avoid font extension
FONTNAME = "roboto"

require enigma2-fonts.inc
