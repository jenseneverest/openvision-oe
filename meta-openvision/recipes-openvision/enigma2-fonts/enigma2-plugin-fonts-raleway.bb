# Avoid font extension
FONTNAME = "raleway"

require enigma2-fonts.inc
