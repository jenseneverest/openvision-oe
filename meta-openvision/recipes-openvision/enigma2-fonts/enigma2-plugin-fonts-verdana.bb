# Avoid font extension
FONTNAME = "verdana"

require enigma2-fonts.inc
