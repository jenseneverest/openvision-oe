# Avoid font extension
FONTNAME = "lcd"

require enigma2-fonts.inc
