# Avoid font extension
FONTNAME = "nmsbd2"

require enigma2-fonts.inc
