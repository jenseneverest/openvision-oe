require frequency-xml-list.inc

FREQUENCY_LIST = "atsc.xml"
