require frequency-xml-list.inc

FREQUENCY_LIST = "cables.xml"
