require frequency-xml-list.inc

FREQUENCY_LIST = "satellites-atlantic.xml"
