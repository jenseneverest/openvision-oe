require frequency-xml-list.inc

FREQUENCY_LIST = "terrestrial.xml"
