require frequency-xml-list.inc

FREQUENCY_LIST = "satellites-asia.xml"
