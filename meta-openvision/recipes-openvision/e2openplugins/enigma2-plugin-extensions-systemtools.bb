MODULE = "SystemTools"
DESCRIPTION = "System Tools for enigma2 stb"

require conf/license/license-gplv2.inc
require openplugins-replace-vision.inc
require openplugins-distutils.inc
