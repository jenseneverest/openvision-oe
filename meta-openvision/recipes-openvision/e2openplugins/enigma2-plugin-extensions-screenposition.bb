MODULE = "ScreenPosition"
DESCRIPTION = "Adjust the screen position"

require conf/license/license-gplv2.inc
require openplugins-replace-vision.inc
require openplugins-distutils.inc
