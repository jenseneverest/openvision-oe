MODULE = "SetPicon"
DESCRIPTION = "Work with services picons"

require conf/license/license-gplv2.inc
require openplugins-replace-vision.inc
require openplugins-distutils.inc
