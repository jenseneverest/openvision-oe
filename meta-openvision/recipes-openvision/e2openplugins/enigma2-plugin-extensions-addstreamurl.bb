MODULE = "AddStreamUrl"
DESCRIPTION = "Add a stream url to your channellist"

require conf/license/license-gplv2.inc
require openplugins-replace-vision.inc
require openplugins-distutils.inc
