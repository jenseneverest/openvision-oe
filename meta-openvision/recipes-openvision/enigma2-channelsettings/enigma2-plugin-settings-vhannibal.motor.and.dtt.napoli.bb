SUMMARY = "Vhannibal Motor E2 Settings File"

SETTINGS_FILENAME = "vhannibal.motor.and.dtt.napoli"

include settings-vhannibal.inc
