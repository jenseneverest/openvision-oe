DESCRIPTION = "Morph883 9E-13E channel settings"

SETTINGS_FILENAME = "morph883_9e-13e"

include settings-morph883.inc
