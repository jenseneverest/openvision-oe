SUMMARY = "Vhannibal E2 Settings File Quad Nordic"

SETTINGS_FILENAME = "vhannibal.quad.nordic"

include settings-vhannibal.inc
