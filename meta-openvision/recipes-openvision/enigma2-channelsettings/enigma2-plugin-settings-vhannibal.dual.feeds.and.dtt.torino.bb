SUMMARY = "Vhannibal Dual Feeds E2 Settings File"

SETTINGS_FILENAME = "vhannibal.dual.feeds.and.dtt.torino"

include settings-vhannibal.inc
