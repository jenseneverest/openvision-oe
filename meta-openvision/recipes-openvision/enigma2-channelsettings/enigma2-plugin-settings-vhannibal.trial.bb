SUMMARY = "Vhannibal E2 Settings File trial"

SETTINGS_FILENAME = "vhannibal.trial"

include settings-vhannibal.inc
