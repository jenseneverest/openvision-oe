SUMMARY = "Vhannibal E2 Settings File For HotBird"

SETTINGS_FILENAME = "vhannibal.hotbird.and.dtt.torino"

include settings-vhannibal.inc
