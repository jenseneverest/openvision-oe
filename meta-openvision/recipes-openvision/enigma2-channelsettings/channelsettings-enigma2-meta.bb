require conf/license/openvision-gplv2.inc

DESCRIPTION = "meta file for settings"

DEPENDS = "\
	enigma2-plugin-extensions-ngsetting \
	enigma2-plugin-settings-chveneburi \
	enigma2-plugin-settings-ciefp-19e.16e.13e.0.8w \
	enigma2-plugin-settings-ciefp-19e.16e.13e.1.9e.0.8w \
	enigma2-plugin-settings-ciefp-19e.16e.13e \
	enigma2-plugin-settings-ciefp-19e.16e \
	enigma2-plugin-settings-ciefp-19e \
	enigma2-plugin-settings-ciefp-23e.19e.16e.13e.1.9e.0.8w \
	enigma2-plugin-settings-ciefp-23e.19e.16e.13e.4.8e.1.9e.0.8w \
	enigma2-plugin-settings-ciefp-39e.23e.19e.16e.13e.4.8e.1.9e.0.8w \
	enigma2-plugin-settings-ciefp-motor.68e.30w.vod \
	enigma2-plugin-settings-gioppygio-dual \
	enigma2-plugin-settings-gioppygio-dual.13e.19e.dtt-italia \
	enigma2-plugin-settings-gioppygio-dual.5w.13e \
	enigma2-plugin-settings-gioppygio-dual.9e.13e \
	enigma2-plugin-settings-gioppygio-mono \
	enigma2-plugin-settings-gioppygio-mono.13e.dtt-italia \
	enigma2-plugin-settings-gioppygio-motor \
	enigma2-plugin-settings-gioppygio-motor.75e.45w.dtt-italia \
	enigma2-plugin-settings-gioppygio-quadri \
	enigma2-plugin-settings-gioppygio-quadri.13e.19e.9e.5w \
	enigma2-plugin-settings-gioppygio-quadri.9e.13e.16e.19e \
	enigma2-plugin-settings-gioppygio-trial \
	enigma2-plugin-settings-gioppygio-trial.13e.19e.30w \
	enigma2-plugin-settings-gioppygio-trial.5w.13e.19e \
	enigma2-plugin-settings-gioppygio-trial.9e.13e.19e \
	enigma2-plugin-settings-hans-19e-23e \
	enigma2-plugin-settings-hans-19e-23e-basis \
	enigma2-plugin-settings-hans-19e-23e-28e \
	enigma2-plugin-settings-hans-13e-19e-23e-28e \
	enigma2-plugin-settings-hans-9e-13e-19e-23e-28e \
	enigma2-plugin-settings-hans-9e-13e-19e-23e-28e-rotating \
	enigma2-plugin-settings-hans-kabelnl \
	enigma2-plugin-settings-morph883-0.8w-13e-19.2e-28.2e \
	enigma2-plugin-settings-morph883-0.8w-13e-19.2e \
	enigma2-plugin-settings-morph883-0.8w-13e \
	enigma2-plugin-settings-morph883-0.8w-4.8e-13e \
	enigma2-plugin-settings-morph883-13e-16e-19.2e-23.5e \
	enigma2-plugin-settings-morph883-13e-16e-19.2e \
	enigma2-plugin-settings-morph883-13e-16e \
	enigma2-plugin-settings-morph883-13e-19.2e-23.5e \
	enigma2-plugin-settings-morph883-13e-19.2e-23.5e-28.2e \
	enigma2-plugin-settings-morph883-13e-19.2e-28.2e \
	enigma2-plugin-settings-morph883-13e-19.2e-42e \
	enigma2-plugin-settings-morph883-13e-19.2e \
	enigma2-plugin-settings-morph883-13e-23.5e \
	enigma2-plugin-settings-morph883-13e-28.2e \
	enigma2-plugin-settings-morph883-13e-42e \
	enigma2-plugin-settings-morph883-13e \
	enigma2-plugin-settings-morph883-30w-13e-19.2e \
	enigma2-plugin-settings-morph883-30w-13e \
	enigma2-plugin-settings-morph883-4.8e-13e-19.2e \
	enigma2-plugin-settings-morph883-4.8e-13e \
	enigma2-plugin-settings-morph883-9e-13e-19.2e \
	enigma2-plugin-settings-morph883-9e-13e \
	enigma2-plugin-settings-morph883-motor \
	enigma2-plugin-settings-vhannibal.dual.feeds.and.dtt.italia \
	enigma2-plugin-settings-vhannibal.dual.feeds.and.dtt.milano \
	enigma2-plugin-settings-vhannibal.dual.feeds.and.dtt.napoli \
	enigma2-plugin-settings-vhannibal.dual.feeds.and.dtt.roma \
	enigma2-plugin-settings-vhannibal.dual.feeds.and.dtt.torino \
	enigma2-plugin-settings-vhannibal.dual.feeds \
	enigma2-plugin-settings-vhannibal.hotbird.and.dtt.italia \
	enigma2-plugin-settings-vhannibal.hotbird.and.dtt.milano \
	enigma2-plugin-settings-vhannibal.hotbird.and.dtt.napoli \
	enigma2-plugin-settings-vhannibal.hotbird.and.dtt.roma \
	enigma2-plugin-settings-vhannibal.hotbird.and.dtt.torino \
	enigma2-plugin-settings-vhannibal.hotbird \
	enigma2-plugin-settings-vhannibal.motor.and.dtt.forli \
	enigma2-plugin-settings-vhannibal.motor.and.dtt.italia \
	enigma2-plugin-settings-vhannibal.motor.and.dtt.milano \
	enigma2-plugin-settings-vhannibal.motor.and.dtt.napoli \
	enigma2-plugin-settings-vhannibal.motor.and.dtt.roma \
	enigma2-plugin-settings-vhannibal.motor.and.dtt.torino \
	enigma2-plugin-settings-vhannibal.motor \
	enigma2-plugin-settings-vhannibal.quad.13e.19e.23e.28e \
	enigma2-plugin-settings-vhannibal.quad.7e.13e.19e.42e \
	enigma2-plugin-settings-vhannibal.quad.9e.13e.16e.19e \
	enigma2-plugin-settings-vhannibal.quad.nordic \
	enigma2-plugin-settings-vhannibal.trial \
	"
