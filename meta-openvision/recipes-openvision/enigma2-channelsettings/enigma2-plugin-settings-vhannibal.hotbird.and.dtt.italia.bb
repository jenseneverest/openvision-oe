SUMMARY = "Vhannibal E2 Settings File For HotBird"

SETTINGS_FILENAME = "vhannibal.hotbird.and.dtt.italia"

include settings-vhannibal.inc
