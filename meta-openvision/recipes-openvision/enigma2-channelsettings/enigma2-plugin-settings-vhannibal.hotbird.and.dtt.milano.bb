SUMMARY = "Vhannibal E2 Settings File For HotBird"

SETTINGS_FILENAME = "vhannibal.hotbird.and.dtt.milano"

include settings-vhannibal.inc
