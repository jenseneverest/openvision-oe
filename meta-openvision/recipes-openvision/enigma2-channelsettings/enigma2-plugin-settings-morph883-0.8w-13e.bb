DESCRIPTION = "Morph883 0.8W-13E channel settings"

SETTINGS_FILENAME = "morph883_0.8w-13e"

include settings-morph883.inc
