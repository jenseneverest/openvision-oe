SUMMARY = "Vhannibal E2 Settings File For HotBird"

SETTINGS_FILENAME = "vhannibal.hotbird.and.dtt.roma"

include settings-vhannibal.inc
