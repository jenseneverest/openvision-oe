SUMMARY = "Vhannibal Motor E2 Settings File"

SETTINGS_FILENAME = "vhannibal.motor.and.dtt.italia"

include settings-vhannibal.inc
