# Just a comment line to avoid PAK archive (application/x-pak)

PACKAGE_ARCH = "${MACHINE_ARCH}"
