RDEPENDS_${PN} = "libltdl"
