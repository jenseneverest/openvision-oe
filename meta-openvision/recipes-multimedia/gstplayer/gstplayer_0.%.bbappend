SRC_URI = "git://github.com/OpenVisionE2/gstplayer.git \
	file://0001-set-iptv-download-timeout-0-to-disable-ifdsrc.patch \
	file://0004-rename-stored-sink-to-dvbSink-for-clarity.patch \
	file://0009-try-to-get-PTS-from-video-sink-first.patch \
	file://0011-increase-eos-fix-timeout-to-10s.patch \
"
