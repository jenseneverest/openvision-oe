CFLAGS_append_cube += " -std=gnu11"
CFLAGS_append_su980 += " -std=gnu11"
