SRC_URI = "git://github.com/OpenVisionE2/gst-ifdsrc.git"
