EXTRA_OEMESON += "${GSTREAMER1_DEBUG}"
