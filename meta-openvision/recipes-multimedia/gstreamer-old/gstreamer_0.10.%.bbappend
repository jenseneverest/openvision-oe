COMPATIBLE_MACHINE = "^(wetekplay|wetekplay2|wetekhub|odroidc2)$"
