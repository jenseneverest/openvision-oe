SRC_URI = "https://git.linuxtv.org/edid-decode.git;protocol=https"
