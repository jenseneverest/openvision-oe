RDEPENDS_packagegroup-base-bluetooth = "\
    ${BLUEZ} \
    "

RDEPENDS_packagegroup-base += "\
    stb-hwclock \
    fake-hwclock"
