TZONES_remove += "systemv"

TZ_PACKAGES_remove += "tzdata-posix tzdata-right"

RPROVIDES_tzdata-posix_remove += "tzdata-posix"

RPROVIDES_tzdata-right_remove += "tzdata-right"

DEFAULT_TIMEZONE = "Europe/London"
