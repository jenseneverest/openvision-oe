inherit upx_compress

ALTERNATIVE_${PN} = ""
