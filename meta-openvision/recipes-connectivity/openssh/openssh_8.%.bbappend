inherit upx_compress

