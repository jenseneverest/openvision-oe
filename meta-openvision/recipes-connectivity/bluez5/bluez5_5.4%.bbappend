PNBLACKLIST[bluez5] ="Conflicts with 5.50"
