FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://i-am-tired-of-this-shit.patch"
