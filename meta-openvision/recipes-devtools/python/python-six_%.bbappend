include python-package-split.inc

BBCLASSEXTEND = "native"
