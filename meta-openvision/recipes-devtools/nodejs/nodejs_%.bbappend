FILESEXTRAPATHS_prepend := "${THISDIR}/nodejs:"

SRC_URI += "file://fix_mips_build.patch"
