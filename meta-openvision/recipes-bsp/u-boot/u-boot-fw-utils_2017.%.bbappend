FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://ssl111.patch"
