SRC_URI = "git://github.com/OpenVisionE2/bitstream.git"
