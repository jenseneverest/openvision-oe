SRC_URI = "git://github.com/OpenVisionE2/uchardet.git"
