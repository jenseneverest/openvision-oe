inherit upx_compress

RDEPENDS_ntfs-3g += "kernel-module-ntfs"
