RDEPENDS_packagegroup-base-bluetooth = "\
    ${BLUEZ} \
    "
